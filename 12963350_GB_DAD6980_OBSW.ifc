Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: cdfa3021-6d6e-4f7e-83d0-827c61a89540, NumberOfSaves: 1]
File name: 0001
Time: 2026-10-12T07:27:20+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12963350_GB_DAD6980_OBSW:28D6980B_GB_12963350_DAD6980_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, Výchozí Nový materiál, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 936 mm; Depth: 171 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28D6980B_GB_12963350_DAD6980_OBSW; sets with these values: 2

# IfcDistributionPort, Port_351299_1
Description: Flow; FlowDirection: SOURCEANDSINK
